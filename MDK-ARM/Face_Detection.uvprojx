# Keil uVision project Face_Detection.uvprojx, settings and files
target Face_Detection_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x10000000-0x10047FFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Face_Detection_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx,USE_PWR_SMPS_2V5_SUPPLIES_EXT
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: stm32h747xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c gpio.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c ai_detection.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/BSP/Components
    ../BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../BSP/Components/adv7533/: adv7533.c adv7533_reg.c
    ../BSP/Components/nt35510/: nt35510.c nt35510_reg.c
    ../BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/STM32H747I_DISCO
    ../BSP/STM32H747I-DISCO/: stm32h747i_discovery.c stm32h747i_discovery_bus.c stm32h747i_discovery_lcd.c stm32h747i_discovery_sdram.c
  group Utilities
    ../BSP/Utilities/lcd/: stm32_lcd.c
  group Application/User/AI/App
    ../AI/App/: app_x-cube-ai.c user_init.c network_weights.c
  group Application/User/AI/Network
    ../ai_generated_network/: network.c network_data.c
  group Middlewares/ST/AI
    ../Middlewares/ST/AI/Misc/Src/: lc_print.c aiTestUtility.c ai_device_adaptor.c
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1201_CM7_Keil.lib
target Face_Detection_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Face_Detection_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx,USE_PWR_SMPS_2V5_SUPPLIES_EXT
  c include: ../CM7/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\BSP\Components\Common;..\BSP\STM32H747I-DISCO;..\BSP\Utilities\CPU;..\BSP\Utilities\Fonts;..\BSP\Utilities\lcd;..\BSP\Inc;..\AI\App;..\ai_generated_network;..\Middlewares\ST\AI\Inc;..\Middlewares\ST\AI\Misc\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h747xx_flash_CM7.sct
software components: CMSIS:CORE 4.3.0
